<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Switch Based ISR to Task using Binary Semaphore.ewp</path>
  </project>
  <batchBuild />
</workspace>
