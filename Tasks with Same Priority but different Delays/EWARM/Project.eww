<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tasks with Same Priority but different Delays.ewp</path>
  </project>
  <batchBuild />
</workspace>
