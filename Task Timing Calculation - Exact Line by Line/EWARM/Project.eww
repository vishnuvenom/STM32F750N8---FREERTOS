<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Task Timing Calculation - Exact Line by Line.ewp</path>
  </project>
  <batchBuild />
</workspace>
