<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Counting Semaphore with 5 tasks.ewp</path>
  </project>
  <batchBuild />
</workspace>
