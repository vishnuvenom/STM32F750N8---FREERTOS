<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Binary Semaphore Task to Task.ewp</path>
  </project>
  <batchBuild />
</workspace>
