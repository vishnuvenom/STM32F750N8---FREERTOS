<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Queue Blcoking and Non Blocking Demo.ewp</path>
  </project>
  <batchBuild />
</workspace>
