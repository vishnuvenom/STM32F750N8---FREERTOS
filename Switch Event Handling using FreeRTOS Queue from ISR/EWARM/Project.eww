<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Switch Event Handling using FreeRTOS Queue from ISR.ewp</path>
  </project>
  <batchBuild />
</workspace>
