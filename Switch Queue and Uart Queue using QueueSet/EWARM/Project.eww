<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Switch Queue and Uart Queue using QueueSet.ewp</path>
  </project>
  <batchBuild />
</workspace>
